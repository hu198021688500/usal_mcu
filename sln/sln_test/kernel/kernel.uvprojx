# Keil uVision project kernel.uvprojx, settings and files
target user (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: kernel (library)
  AfterMake: xcopy ".\_build\obj\kernel.lib" "..\out" /y
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\public\inc\lib\ofc;..\..\..\public\inc\lib\mfc;..\..\..\public\inc\lib\pfc;..\..\..\public\inc\arch\drv;..\..\..\kernel\inc\dev;..\..\..\kernel\inc\mem;..\..\..\kernel\inc\srt;..\..\..\kernel\inc\vfs;..\..\..\kernel\inc\thread;..\..\..\kernel\inc\rtos\rtx\rtx_config;..\..\..\kernel\inc\rtos\rtx\rtx_inc;..\..\..\kernel\inc\rtos\rtx\rtx_include;..\..\..\kernel\inc\rtos\rtx\rtx_rte\arm_cm4;..\..\..\public\inc\kernel\kfc;..\..\..\public\inc\kernel\config;..\..\..\kernel\inc\rtos\rtx\rtx_compiler;..\..\..\public\inc\kernel;..\..\..\kernel\src\cfg;..\..\..\public\inc\def;..\..\..\public\inc\arch\CMSIS\Include;..\..\..\kernel\inc\per_ext_flash;..\..\..\kernel\inc\per_can_mcp2515;..\..\..\kernel\inc\rtos;..\..\..\kernel\inc\fatfs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group src
    ../../../kernel/src/: kernel_init.c
    ../../../kernel/src/cfg/: dev_init_cfg.c
  group src/kfc
    ../../../kernel/src/kfc/: kfc_system.c kfc_dev.c kfc_memory.c kfc_task.c kfc_timer.c kfc_event.c kfc_mutex.c kfc_srt.c kfc_file.c
  group src/rtos
    ../../../kernel/src/rtos/rtx/rtx_config/: RTX_Config.c
    ../../../kernel/src/rtos/rtx/rtx_source/: os_systick.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ../../../kernel/src/rtos/rtx/rtx_core/ARM/: irq_cm4f.s
    ../../../kernel/src/rtos/rtx/: rtos_api.c
  group src/dev
    ../../../kernel/src/dev/: dev_adc.c dev_can.c dev_flash.c dev_pmu.c dev_power.c dev_pwm.c dev_switch.c dev_wdog.c dev_rs485.c dev_log.c
  group src/vfs
    ../../../kernel/src/vfs/: vfs.c
  group src/mem
    ../../../kernel/src/mem/: memory.c
  group src/thread
    ../../../kernel/src/thread/: thread.c thread_event.c
  group src/srt
    ../../../kernel/src/srt/: srt.c
  group src/per_ext_flash
    ../../../kernel/src/per_ext_flash/: per_ext_flash.c
  group src/per_can_mcp2515
    ../../../kernel/src/per_can_mcp2515/: per_can_mcp2515.c
  group sfc/fatfs
    ../../../kernel/src/fatfs/: ff.c ffsystem.c ffunicode.c diskio.c
