# Keil uVision project app_test.uvprojx, settings and files
target user (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_test (library)
  AfterMake: xcopy ".\_build\obj\app_test.lib" "..\out" /y
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\public\inc\lib\ofc;..\..\..\public\inc\lib\mfc;..\..\..\public\inc\kernel\kfc;..\..\..\public\inc\kernel\config;..\..\..\app\app_test\inc;..\..\..\public\inc\def
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group src
    ../../../app/app_test/src/: test_task.c test_protocol.c com_protocol.c
