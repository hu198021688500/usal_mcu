# Keil uVision project lib.uvprojx, settings and files
target user (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib (library)
  AfterMake: xcopy ".\_build\obj\lib.lib" "..\out" /y
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\public\inc\lib\ofc;..\..\..\public\inc\lib\mfc;..\..\..\public\inc\lib\pfc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group src/ofc
    ../../../lib/src/ofc/: ofc_object.c ofc_chain.c ofc_list.c ofc_ring_buf.c ofc_crc16.c ofc_crc32.c
  group src/mfc
    ../../../lib/src/mfc/: mfc_memory.c
  group src/pfc
    ../../../lib/src/pfc/: pfc_irq_buf.c pfc_sync_objs.c
