# Keil uVision project arch.uvprojx, settings and files
target user (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arch (library)
  AfterMake: xcopy ".\_build\obj\arch.lib" "..\out" /y
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STM324xG_EVAL,USE_USB_OTG_FS
  c include: ..\..\..\arch\inc\stm32f4xx\hal;..\..\..\arch\inc\stm32f4xx\platform;..\..\..\public\inc\arch\drv;..\..\..\public\inc\lib\ofc;..\..\..\public\inc\lib\pfc;..\..\..\arch\inc\stm32f4xx\drv;..\..\..\public\inc\arch\CMSIS\Include;..\..\..\arch\src\stm32f4xx\cfg;..\..\..\public\inc\def;..\..\..\arch\inc\stm32f4xx\hal\usb\core;..\..\..\arch\inc\stm32f4xx\hal\usb\usb_host\config;..\..\..\arch\inc\stm32f4xx\hal\usb\usb_host\host;..\..\..\arch\inc\stm32f4xx\hal\usb\usb_host\msc;..\..\..\arch\inc\stm32f4xx\hal\usb\usb_host\core;..\..\..\arch\inc\stm32f4xx\hal\usb\usb_device\config;..\..\..\arch\inc\stm32f4xx\hal\usb\usb_device\device;..\..\..\arch\inc\stm32f4xx\hal\usb\usb_device\msc;..\..\..\arch\inc\stm32f4xx\hal\usb\usb_device\core
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group src/drv
    ../../../arch/src/stm32f4xx/drv/: drv_adc.c drv_can.c drv_clock.c drv_dma.c drv_ext_int.c drv_flash.c drv_int.c drv_pmu.c drv_port.c drv_pwm.c drv_timer.c drv_uart.c drv_wdog.c drv_spi.c drv_usb.c
  group src/hal
    ../../../arch/src/stm32f4xx/hal/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group src/hal_usb
    ../../../arch/src/stm32f4xx/hal/usb/core/: usb_core.c
  group src/hal_usb_host
    ../../../arch/src/stm32f4xx/hal/usb/usb_host/host/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../../arch/src/stm32f4xx/hal/usb/usb_host/core/: usb_hcd.c usb_hcd_int.c
  group src/hal_usb_hmsc
    ../../../arch/src/stm32f4xx/hal/usb/usb_host/msc/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group src/hal_usb_device
    ../../../arch/src/stm32f4xx/hal/usb/usb_device/core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../arch/src/stm32f4xx/hal/usb/usb_device/device/: usb_dcd.c usb_dcd_int.c
  group src/hal_usb_dmsc
    ../../../arch/src/stm32f4xx/hal/usb/usb_device/msc/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group src/hal_usb_dconfig
    ../../../arch/src/stm32f4xx/hal/usb/usb_device/config/: usbd_desc.c
