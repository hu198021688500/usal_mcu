# Keil uVision project bootldr.uvprojx, settings and files
target usr (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootldr
  AfterMake: fromelf  --bincombined --output=.\_build\bin\USAL_BOOT.bin .\_build\obj\bootldr.axf
  AfterMake: xcopy ".\_build\bin\USAL_BOOT.bin" "..\out" /y
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\..\..\arch\inc\stm32f4xx\platform;..\..\..\bootldr\inc\upgrade;..\..\..\public\inc\lib\ofc;..\..\..\public\inc\lib\mfc;..\..\..\public\inc\arch\drv;..\..\..\public\inc\arch\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group src
    ../../../bootldr/src/: main.c
  group src/startup
    ../../../bootldr/src/startup/armcc/: startup_stm32f413xx.s
  group src/upgrade
    ../../../bootldr/src/upgrade/: upgrade.c
  group lib
    ../out/: arch.lib lib.lib
