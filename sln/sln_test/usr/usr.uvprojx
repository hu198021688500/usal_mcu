# Keil uVision project usr.uvprojx, settings and files
target user (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F413ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usr
  AfterMake: fromelf  --bincombined --output=.\_build\bin\USAL_APP.bin .\_build\obj\usr.axf
  AfterMake: xcopy ".\_build\bin\USAL_APP.bin" "..\out" /y
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\public\inc\lib\ofc;..\..\..\public\inc\lib\mfc;..\..\..\public\inc\kernel;..\..\..\public\inc\kernel\kfc;..\..\..\public\inc\arch\platform;..\..\..\public\inc\arch\CMSIS\Include;..\..\..\arch\inc\stm32f4xx\platform;..\..\..\app\app_test\inc;..\..\..\public\inc\def;..\..\..\app\app_hmi\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group src
    ../../../usr/usr_test/: main.c
  group src/startup
    ../../../usr/src/startup/armcc/: startup_stm32f413xx.s
  group lib
    ../out/: lib.lib arch.lib kernel.lib app_test.lib app_hmi.lib
